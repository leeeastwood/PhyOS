# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H_DISCOVERY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,MBEDTLS_CONFIG_FILE=<aws_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,AWS,STM32F413xx,USE_WIFI
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../Inc;../../../../../Common/AWS/inc;../../../../../Common/Shared/inc;../../../../../../Middlewares/Third_Party/AWS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413H_Discovery.sct
  group Application/Common
    ../../../../../Common/Shared/Src/: entropy_hardware_poll.c iot_flash_config.c net.c wifi_net.c timedate.c net_tcp_wifi.c net_tls_mbedtls.c cloud.c rfu.c net_tcp_lwip.c mbedtls_net.c heap.c http_util.c STM32CubeRTCInterface.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_hash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rng.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_dac.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c stm32f4xx_hal_nand.c stm32f4xx_hal_sram.c stm32f4xx_hal_adc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_lptim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_crc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_rtc.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecp_curves.c ssl_ciphersuites.c x509write_crt.c x509_crt.c havege.c ssl_tls.c ecdsa.c ecjpake.c des.c x509_crl.c version_features.c x509write_csr.c x509_csr.c error.c ecp.c camellia.c certs.c x509_create.c pem.c ccm.c pk_wrap.c ripemd160.c memory_buffer_alloc.c entropy_poll.c ssl_srv.c ssl_cli.c md4.c gcm.c hmac_drbg.c md5.c x509.c asn1parse.c bignum.c blowfish.c cipher.c entropy.c arc4.c ctr_drbg.c ssl_cache.c debug.c aes.c asn1write.c threading.c md_wrap.c oid.c pkcs12.c md2.c pkwrite.c dhm.c cmac.c pkcs11.c sha512.c timing.c ssl_cookie.c pkparse.c pk.c platform.c ssl_ticket.c md.c cipher_wrap.c base64.c padlock.c rsa.c aesni.c sha1.c version.c ecdh.c sha256.c pkcs5.c xtea.c
  group Application/AWS
    ../../../../../Common/AWS/Src/: aws_network_st_wrapper.c aws_subscribe_publish_sensor_values.c aws_timer.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_yield.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client.c aws_iot_mqtt_client_subscribe.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c flash_f4.c main.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/Wifi
    ../Src/: es_wifi_io.c wifi.c
software components: CMSIS:CORE 4.3.0
