# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<aws_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,AWS,HAS_RTOS,USE_LWIP
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/include;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../Inc;../../../../../Common/AWS/inc;../../../../../Common/Shared/inc;../../../../../../Middlewares/Third_Party/AWS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc;ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\STM32F769I_Discovery.sct
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Core
    ../../../../../../Middlewares/Third_Party/LWIP/src/core/: mem.c timeouts.c
  group LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LWIP/src/core/ipv4/: etharp.c autoip.c dhcp.c icmp.c igmp.c ip4_addr.c ip4.c ip4_frag.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group LwIP/Api
    ../../../../../../Middlewares/Third_Party/LWIP/src/api/: netbuf.c api_msg.c tcpip.c api_lib.c err.c netifapi.c netdb.c sockets.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dac.c stm32f7xx_hal_flash.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_cryp.c stm32f7xx_ll_fmc.c stm32f7xx_hal_lptim.c stm32f7xx_hal_eth.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_pwr.c stm32f7xx_hal_spi.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_nand.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_usart.c stm32f7xx_hal_rng.c stm32f7xx_hal_hash.c stm32f7xx_hal_dma.c stm32f7xx_hal_nor.c
  group LwIP/System
    ../../../../../../Middlewares/Third_Party/LWIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c tasks.c list.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: ethernetif.c stm32f7xx_hal_timebase_tim.c flash_f7.c stm32f7xx_it.c stm32f7xx_hal_msp.c main.c
  group LwIP/Core
    ../../../../../../Middlewares/Third_Party/LWIP/src/core/: raw.c tcp_out.c init.c memp.c netif.c stats.c inet_chksum.c pbuf.c sys.c dns.c def.c udp.c tcp.c tcp_in.c ip.c
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_yield.c
  group Application/Common
    ../../../../../Common/Shared/Src/: timedate.c http_util.c net_tcp_wifi.c lwip_net.c STM32CubeRTCInterface.c heap.c net_tls_mbedtls.c cloud.c entropy_hardware_poll.c iot_flash_config.c net.c rfu.c mbedtls_net.c net_tcp_lwip.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: pem.c ssl_srv.c md4.c ctr_drbg.c hmac_drbg.c aes.c ssl_cache.c ecdsa.c ssl_cookie.c padlock.c x509_crt.c ccm.c x509_crl.c x509_csr.c des.c ssl_ciphersuites.c pk.c x509write_csr.c x509write_crt.c ecp.c cmac.c ssl_tls.c oid.c error.c dhm.c camellia.c havege.c gcm.c asn1write.c blowfish.c md5.c asn1parse.c cipher.c bignum.c debug.c x509.c arc4.c sha512.c entropy_poll.c ssl_cli.c ssl_ticket.c aesni.c pkcs11.c memory_buffer_alloc.c pkparse.c cipher_wrap.c entropy.c version_features.c pk_wrap.c md2.c ripemd160.c platform.c rsa.c ecjpake.c x509_create.c timing.c certs.c pkwrite.c pkcs5.c threading.c version.c sha1.c xtea.c md_wrap.c pkcs12.c md.c ecdh.c ecp_curves.c base64.c sha256.c
  group LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LWIP/src/netif/: lowpan6.c ethernet.c
  group Application/AWS
    ../../../../../Common/AWS/Src/: aws_network_st_wrapper.c aws_timer.c aws_subscribe_publish_sensor_values.c
software components: CMSIS:CORE 4.3.0
